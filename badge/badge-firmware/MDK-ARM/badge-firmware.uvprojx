# Keil uVision project badge-firmware.uvprojx, settings and files
target badge-firmware (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: badge-firmware +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F1_HAL
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Badge;../Radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xaf00
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: i2c.c tim.c gpio.c stm32f1xx_it.c usb_device.c stm32f1xx_hal_msp.c main.c usbd_cdc_if.c usart.c usbd_desc.c dma.c spi.c usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_ll_usb.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pcd.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Badge
    ../Badge/: badge.cpp fonts.cpp gui.cpp Keyboard.cpp KeyStore.cpp ssd1306.cpp
  group Radio
    ../Radio/: HardwareSPI.cpp RH_RF69.cpp RHGenericDriver.cpp RHGenericSPI.cpp RHHardwareSPI.cpp RHSPIDriver-stm32f1-hal.cpp
software components: CMSIS:CORE 4.1.0
